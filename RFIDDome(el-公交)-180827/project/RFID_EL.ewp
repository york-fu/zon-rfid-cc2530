# IAR project RFID_EL.ewp, settings and files
configuration Release (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\app; ..\source\led; ..\source\key; ..\source\sys; ..\source\time; ..\source\uart; ..\source\rfid_el; ..\source\iic; ..\source\oled; ..\source\relay; ..\source\info
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group (top)
    ./: readme.txt
  group app
    ../app/: main.c
  group source
    ../source/rfid_el/: el.c
    ../source/iic/: iic.c
    ../source/key/: key.c
    ../source/led/: led.c
    ../source/oled/: oled.c
    ../source/relay/: relay.c
    ../source/sys/: sys.c
    ../source/time/: time.c
    ../source/uart/: uart.c
